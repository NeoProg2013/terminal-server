<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\terminal-server.ewp</path>
    </project>
    <batchBuild />
</workspace>
